## Kconfig
```kconfig
# Techpack Config

source "techpack/camera/Kconfig"
source "techpack/dataipa/config/Kconfig"
```
